## boards/shields/macropad/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD

config ZMK_KEYBOARD_NAME
    default "MyMacropad"

config ZMK_KSCAN_MATRIX_POLLING
    default y

endif
```
